Commit message: Starting large change

File: tf_robot_learning/data/urdf/walker_description/urdf/walker.urdf (robot description, URDF)
Before this commit: robot walker, 63 links, 62 joints
Links:
- link torso: mass 1.64221424158838 -> 3.24221424158838
